# Keil uVision project dumber2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dumber2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: C:\Keil\stm32lib\stm32f10x\peripherals\inc;C:\Keil\stm32lib\stm32f10x\peripherals\inc\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    C:/Keil/stm32lib/stm32f10x/peripherals/src/: stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c
  group App
    ./: gestionCmde.c main.c system_dumby.c cmde_usart.c Battery.c motor.c led.c
    ./Boot/: system_stm32f10x.c
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-rvds.s
software components: CMSIS:CORE 4.3.0
