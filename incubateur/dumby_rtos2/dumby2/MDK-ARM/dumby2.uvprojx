# Keil uVision project dumby2.uvprojx, settings and files
target dumby2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dumby2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,__DEBUG__
  c misc: --c99
  c include: ../Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;          ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;          ../Middlewares/Third_Party/FreeRTOS/Source/include;          ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;          ../Drivers/CMSIS/Include
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c tasks.c timers.c croutine.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c freertos.c main.c stm32f1xx_it.c stm32f1xx_hal_timebase_TIM.c usart.c adc.c dma.c gpio.c tim.c mRequest.c sharedData.c
    ../Inc/: common.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group DriversPerso
    ../Src/: Battery.c Com.c Led.c Motor.c serviceCom.c Xbee.c
software components: CMSIS:CORE 4.1.0
